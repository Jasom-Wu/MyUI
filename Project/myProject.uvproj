# Keil uVision project myProject.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x_begFFF) CLOCK(24000000)
  output: myProject +hex
  c flags: Optimize=8
  c include: ..\Code
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51
    ../Code/: base_timer.c bsp_task.c bsp_tm7705.c bsp_uart.c i2c.c main.c my_ui.c oled.c codetab.c
